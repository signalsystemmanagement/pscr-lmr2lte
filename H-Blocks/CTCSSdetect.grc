options:
  parameters:
    generate_options: hb
    id: CTCSSdetect
    output_language: python
    title: CTCSS Detection
  states: {}

blocks:
- name: MaxOutBuf
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: ctcss_detect
  id: variable_function_probe
  parameters:
    block_id: level
    comment: Monitors output of argmax
    function_name: level
    poll_rate: '1000'
    value: '0'
  states: {}
- name: length
  id: variable
  parameters:
    value: int(8*audio_samp_rate/max(50,ctcss))
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: |-
      Trigger when CTCSS
      is detected
    const: ctcss_detect>=2
    maxoutbuf: '2048'
    type: short
  states: {}
- name: audio_samp_rate
  id: parameter
  parameters:
    hide: part
    label: Audio Sample Rate
    type: intx
    value: '48000'
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    comment: |-
      When detected CTCSS signal
      is stronger than frequency 
      above or below CTCSS freq
      max_inp will output 2
    maxoutbuf: '2048'
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: squelch_eob
    false_value: 'True'
    maxoutbuf: MaxOutBuf
    true_key: squelch_sob
    true_value: 'True'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    maxoutbuf: MaxOutBuf
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    maxoutbuf: MaxOutBuf
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters:
    maxoutbuf: MaxOutBuf
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: |-
      Enable only if
      ctcss   frequency>0
    enabled: ctcss>0
    maxoutbuf: MaxOutBuf
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: MaxOutBuf
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: length
    type: short
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    comment: |-
      Block tags from power squelch
      which confuses rtp sink
    maxoutbuf: MaxOutBuf
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Prevent false CTCSS 
      detection on noise
    high: '0.02'
    init: '0'
    low: '0.01'
    maxoutbuf: MaxOutBuf
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    maxoutbuf: '2048'
    samples_per_second: audio_samp_rate
    type: short
  states: {}
- name: ctcss
  id: parameter
  parameters:
    label: CTCSS Frequency
    type: eng_float
    value: '0'
  states: {}
- name: goertzel_fc_0
  id: goertzel_fc
  parameters:
    freq: max(ctcss,67)*0.98
    len: length
    maxoutbuf: MaxOutBuf
    rate: audio_samp_rate
  states: {}
- name: goertzel_fc_0_0
  id: goertzel_fc
  parameters:
    freq: max(ctcss,67)*1.02
    len: length
    maxoutbuf: MaxOutBuf
    rate: audio_samp_rate
  states: {}
- name: goertzel_fc_0_0_0
  id: goertzel_fc
  parameters:
    freq: max(ctcss,67)
    len: length
    maxoutbuf: MaxOutBuf
    rate: audio_samp_rate
  states: {}
- name: level
  id: blocks_probe_signal_x
  parameters:
    type: short
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: ctcss+50
    decim: '1'
    gain: '1'
    maxoutbuf: '16384'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '25'
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    maxoutbuf: MaxOutBuf
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_burst_tagger_0, '1']
- [blocks_argmax_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_argmax_xx_0, '1', blocks_repeat_0, '0']
- [blocks_burst_tagger_0, '0', pad_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_argmax_xx_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_argmax_xx_0, '1']
- [blocks_complex_to_mag_0_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_threshold_ff_1, '0']
- [blocks_copy_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', blocks_argmax_xx_0, '2']
- [blocks_repeat_0, '0', blocks_throttle_1, '0']
- [blocks_tag_gate_0, '0', blocks_burst_tagger_0, '0']
- [blocks_threshold_ff_1, '0', blocks_multiply_xx_0, '1']
- [blocks_throttle_1, '0', level, '0']
- [goertzel_fc_0, '0', blocks_complex_to_mag_0, '0']
- [goertzel_fc_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [goertzel_fc_0_0_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [low_pass_filter_0, '0', goertzel_fc_0, '0']
- [low_pass_filter_0, '0', goertzel_fc_0_0, '0']
- [low_pass_filter_0, '0', goertzel_fc_0_0_0, '0']
- [pad_source_0, '0', blocks_copy_0, '0']
- [pad_source_0, '0', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
